# Keil uVision project OpenBootloader.uvprojx, settings and files
target NUCLEO_WL55JC2 (6140001::V6.14.1::ARMCLANG)
  device: STM32WL55JCIx:CM4 STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.1
  cpu: IROM(0x08000000-0x80037FF) IRAM(0x20000000-0x200013FF) IRAM2(0x20008000-0x2000BFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") TZ
  output: OpenBootloader +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,STM32WL55xx,USE_FULL_LL_DRIVER
  c include: ../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../Drivers/CMSIS/Include;../Core/Inc;../OpenBootloader/App;../OpenBootloader/Target;../../../../../Middlewares/ST/OpenBootloader/Modules/USART;../../../../../Middlewares/ST/OpenBootloader/Modules/SPI;../../../../../Middlewares/ST/OpenBootloader/Modules/Mem;../../../../../Middlewares/ST/OpenBootloader/Core
  memory RVCT4: ROM 0x8000000 size 0x3800
  memory RVCT9: RAM 0x20000000 size 0x1400
  memory RVCT10: RAM 0x20008000 size 0x4000
  scatter file: stm32wl55xx_flash_cm4.sct
  group Application/Core
    ../Core/Src/: main.c stm32wlxx_it.c
  group Application/MDK-ARM
    ./: startup_stm32wl55xx_cm4.s
  group Application/OpenBootloader/App
    ../OpenBootloader/App/: app_openbootloader.c
  group Application/OpenBootloader/Target
    ../OpenBootloader/Target/: common_interface.c engibytes_interface.c flash_interface.c iwdg_interface.c optionbytes_interface.c otp_interface.c ram_interface.c spi_interface.c systemmemory_interface.c usart_interface.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_cortex.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_iwdg.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_spi.c stm32wlxx_hal_spi_ex.c stm32wlxx_hal_usart.c stm32wlxx_hal_usart_ex.c stm32wlxx_ll_gpio.c stm32wlxx_ll_rcc.c stm32wlxx_ll_spi.c stm32wlxx_ll_usart.c
  group Middlewares/Core
    ../../../../../Middlewares/ST/OpenBootloader/Core/: openbl_core.c
  group Middlewares/Modules/MEM
    ../../../../../Middlewares/ST/OpenBootloader/Modules/Mem/: openbl_mem.c
  group Middlewares/Modules/SPI
    ../../../../../Middlewares/ST/OpenBootloader/Modules/SPI/: openbl_spi_cmd.c
  group Middlewares/Modules/USART
    ../../../../../Middlewares/ST/OpenBootloader/Modules/USART/: openbl_usart_cmd.c
software components: CMSIS:CORE 4.3.0
